# Repository mstrthealias/TeensyFanController

File README.md:

# Teensy Fan Controller

*Documentation: [https://mstrthealias.gitbook.io/teensy-fan-controller/][7]*

A PC fan controller with temperature sensor input, for **[Teensy](https://www.pjrc.com/teensy/index.html) 3.x** USB Development Board(s).

Supports up to 6 fans (4pin/PWM), and up to 5 temperature sensors. Each fan may individually operate in PID, temperature-percent table, or fixed-percent control modes. Configuration is saved onto the device, and software is not required other than to configure the controller.

## Documentation

The project is **documented using Gitbook**, and accessible at **[https://mstrthealias.gitbook.io/teensy-fan-controller/][7]**.

## Releases

- v0.1.0
  - [Firmware (Teensy 3.2, 3.5)](https://github.com/mstrthealias/TeensyFanController/releases/tag/v0.1.0)
  - [Configuration UI (Windows 10)](https://github.com/mstrthealias/TFC-ui/releases/tag/v0.1.0)

## Hardware

* [Prototype - Simple PCB][4]: requires PCB fabrication (gerber files provided) and through-hole soldering
* [Prototype - Breadboard][2]: breadboard example with a single fan/single sensor
* [Prototype - Hand-made (Schmart Board based)][3]: uses over-the-shelf components (OK for single fan/single sensor builds)

## Software

### Qt UI

[Teensy Fan Controller UI (Qt5)](https://github.com/mstrthealias/TFC-ui): provides a user interface to configure or monitor the fan controller (only needed for initial configuration).

### Linux Kernel module (hwmon)

[Fork of liquidtux](https://github.com/mstrthealias/liquidtux): Linux kernel module for reading temperatures and fan RPMs using *lm-sensors* or *psensor*.  Tested on Ubuntu 18.04.

## Simple 001 PCB

## [Credits](https://mstrthealias.gitbook.io/teensy-fan-controller/credits)

Icons made by [Freepik](https://www.flaticon.com/authors/freepik) from [www.flaticon.com](https://www.flaticon.com/):

* ui_qt5/images/log.svg
* ui_qt5/images/worldwide.svg

[2]: https://mstrthealias.gitbook.io/teensy-fan-controller/hardware/breadboard
[3]: https://mstrthealias.gitbook.io/teensy-fan-controller/hardware/prototype
[4]: https://mstrthealias.gitbook.io/teensy-fan-controller/hardware/simple-pcb
[5]: Hardware/
[6]: https://mstrthealias.gitbook.io/teensy-fan-controller/demo/router-cooling-demo
[7]: https://mstrthealias.gitbook.io/teensy-fan-controller/

## EAGLE design Hardware/Simple/EAGLE/simple002.brd

File Hardware/Simple/README.md:

# Teensy Fan Controller - PCB Simple001

The initial, untested, simple Teensy Fan Controller PCB.

Designed to fit in a [Raspberry Pi 3 case][1].

## Instructions

TODO

## Notes

After this revision has been tested, a 2nd revision--Simple002--will be published, possibly removing features such as the AGND-GND bridge and V3.3-AREF jumper.

- The jumper in the middle ties v3.3 to ADC reference voltage

TODO

## Features

TODO

- Supports Teensy 3.x, and Teensy 4.0
- Standard 4pin Molex PC power connector
- Fits in a [Raspberry Pi 3 case][1]
- 6 fans
- 5 temperature sensors

## Paths

| Path | Description |
|----------|-------------|
| [datasheets/][2] | Part datasheets
| [simple001/EAGLE/][3] | EAGLE library, schematic, and board (Simple001)
| [simple001/gerbers.zip][4] | Gerber files for PCB fabrication (Simple001)
| [simple001/parts.csv][5] | Part order list (Simple001)
| [simple001/partslist.txt][6] | Modified EAGLE partlist.txt export (Simple001)
| [simple001/schematic.pdf][7] | Schematic print-out PDF (Simple001)
| [simple001/freeDFM.pdf][8] | freeDFM multi-layer PDF output results (Simple001)

[1]: https://www.microcenter.com/product/614861/micro-connectors-plastic-raspberry-pi-3-model-b-case-kit
[2]: datasheets/
[3]: simple001/EAGLE/
[4]: simple001/gerbers.zip
[5]: simple001/parts.csv
[6]: simple001/partslist.txt
[7]: simple001/schematic.pdf
[8]: simple001/freeDFM.pdf

Parts:
C1, C2, C5: 0.1uF; C2.5-3; MANUFACTURER_PART_NUMBER C320C104M1U5TA7303; DIGIKEY_PART_NUMBER 399-14023-1-ND
C3, C4: 10uF; E2,5-5; MANUFACTURER_PART_NUMBER ULD1H100MDD1TD; DIGIKEY_PART_NUMBER 493-16250-1-ND
D1, D2, D3, D4, D5, D6: 1N4934; DO-41
FAN1: FAN1; FAN4
FAN2: FAN2; FAN4
FAN3: FAN3; FAN4
FAN4: FAN4
FAN5: FAN5; FAN4
FAN6: FAN6; FAN4
HDR1: PWRHDR; 641737-1
R1, R2, R3, R4, R5: 10K; V234/12; MANUFACTURER_PART_NUMBER RNF14FTD10K0; DIGIKEY_PART_NUMBER RNF14FTD10K0CT-ND
R6: JMP; R0402
SH1: SHORTT5; SHORT_TOP-50
TEENSY: TEENSY_3.5_DIL+4; MANUFACTURER_PART_NUMBER DEV-14056; DIGIKEY_PART_NUMBER 1568-1464-ND
TEMP1: TEMP1; SENSOR2
TEMP2: TEMP2; SENSOR2
TEMP3: TEMP3; SENSOR2
TEMP4: TEMP4; SENSOR2
TEMP5: TEMP5; SENSOR2

Connections:
AGND: C2.2, C3.-, R6.2, TEENSY.AGND, TEMP1.2, TEMP2.2, TEMP3.2, TEMP4.2, TEMP5.2
AREF: C2.1, C3.+, R1.1, R2.1, R3.1, R4.1, R5.1, SH1.2, TEENSY.AREF
GND: C1.2, C4.-, C5.2, FAN1.4 (GND), FAN2.4 (GND), FAN3.4 (GND), FAN4.4 (GND), FAN5.4 (GND), FAN6.4 (GND), HDR1.2, HDR1.3, R6.1, TEENSY.GND, TEENSY.GND1 (GND)
HDR_PWM1: FAN1.1 (PWM), TEENSY.3 (3/CAN0-TX/SCL2/PWM)
HDR_PWM2: FAN2.1 (PWM), TEENSY.4 (4/CAN0-RX/SDA2/PWM)
HDR_PWM3: FAN3.1 (PWM), TEENSY.6 (6/PWM)
HDR_PWM4: FAN4.1 (PWM), TEENSY.9 (9/RX2/PWM)
HDR_PWM5: FAN5.1 (PWM), TEENSY.10 (10/TX2/PWM)
HDR_PWM6: FAN6.1 (PWM), TEENSY.22/A8 (22/A8/PWM)
HDR_RPM1: D1.C, FAN1.2 (RPM)
HDR_RPM2: D2.C, FAN2.2 (RPM)
HDR_RPM3: D3.C, FAN3.2 (RPM)
HDR_RPM4: D4.C, FAN4.2 (RPM)
HDR_RPM5: D5.C, FAN5.2 (RPM)
HDR_RPM6: D6.C, FAN6.2 (RPM)
NC_VIN: TEENSY.VIN
NC_VUSB: TEENSY.VUSB
SENSOR1: R1.2, TEENSY.21/A7 (21/A7/PWM), TEMP1.1
SENSOR2: R2.2, TEENSY.20/A6 (20/A6/PWM), TEMP2.1
SENSOR3: R3.2, TEENSY.19/A5 (19/A5/SCL0), TEMP3.1
SENSOR4: R4.2, TEENSY.18/A4 (18/A4/SDA0), TEMP4.1
SENSOR5: R5.2, TEENSY.14/A0 (14/A0/PWM), TEMP5.1
UC_RPM1: D1.A, TEENSY.2 (2/PWM)
UC_RPM2: D2.A, TEENSY.5 (5/PWM)
UC_RPM3: D3.A, TEENSY.7 (7/RX3/PWM)
UC_RPM4: D4.A, TEENSY.8 (8/TX3/PWM)
UC_RPM5: D5.A, TEENSY.11 (11/MOSI0)
UC_RPM6: D6.A, TEENSY.12 (12/MISO0)
V3.3: SH1.1, TEENSY.3.3V, TEENSY.3.3V3 (3.3V)
V12.0: C1.1, C4.+, C5.1, FAN1.3 (V12.0), FAN2.3 (V12.0), FAN3.3 (V12.0), FAN4.3 (V12.0), FAN5.3 (V12.0), FAN6.3 (V12.0), HDR1.1

Notes on the sheet:
Header to connect GND to AGND (not needed in practice?)
Short to connect V3.3 to AREF
Equivilent series resistors for thermistors (1% resistors, same resistance as thermistor nominal resistance)
Fan headers
Thermistor sensor headers
ATX 4pin power header/connector
Teensy 3.x header (also compatible with Teensy 4.0)
Fan RPM signal diodes (incase fans have own pull-up resistors)
Decoupling capacitors

Board: 2 copper layers, 54.3 x 81.3 mm, 31 parts (0 on the bottom side), 28 nets.

File Hardware/Simple/simple002/partslist.txt:

Qty Value            Device           Package          Parts                  Description                                               BUILT_BY    CREATED_BY    DESC                            DIGIKEY_PART_NUMBER MANUFACTURER              MANUFACTURER_PART_NUMBER PACKAGE POPULARITY SPICEPREFIX
3   0.1uF            C2,5-3           C2.5-3           C1, C2, C5             CAPACITOR                                                                           CAP CER 0.1UF 100V Z5U RADIAL   399-14023-1-ND      KEMET                     C320C104M1U5TA7303               38                    
5   10K              R-US_V234/12     V234/12          R1, R2, R3, R4, R5     RESISTOR, American symbol                                                           RES 10K OHM 1/4W 1% AXIAL       RNF14FTD10K0CT-ND   Stackpole Electronics Inc RNF14FTD10K0                                           
1   10uF             CPOL-USE2.5-5    E2,5-5           C3                     POLARIZED CAPACITOR, American symbol                                                CAP ALUM 10UF 20% 50V THRU HOLE 493-16250-1-ND      Nichicon                  ULD1H100MDD1TD                   8          C          
1   10uF             CPOL-USE2.5-5    E2,5-5           C4                     POLARIZED CAPACITOR, American symbol                                                CAP ALUM 10UF 20% 50V THRU HOLE 493-16250-1-ND      Nichicon                  ULD1H100MDD1TD                                         
6   1N4934           1N4934           DO-41            D1, D2, D3, D4, D5, D6 DIODE GEN PURP 400V 1A DO41                                           PCBLayout.com DIODE GEN PURP 100V 1A DO41     1N4934DICT-ND       Diodes Incorporated       1N4934-T                 DO-41                         
1   FAN1             HDR-FAN4         FAN4             FAN1                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   FAN2             HDR-FAN4         FAN4             FAN2                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   FAN3             HDR-FAN4         FAN4             FAN3                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   FAN4             HDR-FAN4         FAN4             FAN4                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   FAN5             HDR-FAN4         FAN4             FAN5                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   FAN6             HDR-FAN4         FAN4             FAN6                   PIN HEADER                                                                          CONN HEADER VERT 4POS 2.54MM    WM4330-ND           Molex                     0470531000                                             
1   JMP              R-US_R0402       R0402            R6                     RESISTOR, American symbol                                                           UNUSED                                                                                                                               
1   JP1              JP1E             JP1              JP1                    JUMPER                                                                              Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116                        61                    
1   PWRHDR           641737-1         641737-1         HDR1                                                                             EMA_UL_Team               CONN HEADER R/A 4POS 5.08MM     A25430-ND           TE Connectivity           641737-1                                               
1   TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY                 DIL version of Teensy 3.5 plus the VUSB/A10/A11/AREF PINS                           TEENSY 3.5 W/ HDRS K64 EVAL BRD 1568-1464-ND        SparkFun Electronics      DEV-14056                                              
1   TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY                 CONN HDR 14POS 0.1 TIN PCB                                                          CONN HDR 14POS 0.1 TIN PCB      S7012-ND            Sullins Connector Solutio PPTC141LFBN-RC                                         
1   TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY                 CONN HDR 15POS 0.1 TIN PCB                                                          CONN HDR 15POS 0.1 TIN PCB      S7013-ND            Sullins Connector Solutio PPTC151LFBN-RC                                         
1   TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY_3.5_DIL+4 TEENSY                 CONN HDR 3POS 0.1 GOLD PCB                                                          CONN HDR 3POS 0.1 GOLD PCB      S7036-ND            Sullins Connector Solutio PPPC031LFBN-RC                                         
1   TEMP1            HDR-SENSOR2      SENSOR2          TEMP1                  PIN HEADER                                                                          Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116                                              
1   TEMP2            HDR-SENSOR2      SENSOR2          TEMP2                  PIN HEADER                                                                          Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116                                              
1   TEMP3            HDR-SENSOR2      SENSOR2          TEMP3                  PIN HEADER                                                                          Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116                                              
1   TEMP4            HDR-SENSOR2      SENSOR2          TEMP4                  PIN HEADER                                                                          Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116                                              
1   TEMP5            HDR-SENSOR2      SENSOR2          TEMP5                  PIN HEADER                                                                          Break Away Headers - Straight   PRT-00116           SparkFun Electronics      PRT-00116

## Commit log

2019-12-18 TFC-0 Initial commit (teensy_fan_controller/) TFC-0 Initial commit (README.md) TFC-0 Initial commit (Hardware/Schmart Board/) TFC-0 Initial commit (firmware/TODO)
2019-12-18 TFC-0 add MIT license
2019-12-29 TFC-0 better c++11
2019-12-29 TFC-0 hid_shared.h + runtime_config compat. for Qt project
2019-12-29 TFC-0 increase default PID step-up case limit to 1.8degC
2019-12-29 TFC-0 track Qt5-HIDAPI + TFC-ui git projects
2019-12-30 TFC-0 gcc-4.7 linux build compat.
2019-12-30 TFC-0 submodules fix
2019-12-30 TFC-0 linux libhidapi-hidraw instead of libusb-1 TFC-0 qa gcc-4.7 linux build compat.
2019-12-30 TFC-0 track latest UI project
2020-01-07 TFC-1 multiple PID + tbl configs TFC-1 HID_CONFIG/HID_DOWNLOAD more config chunks TFC-1 track latest ui
2020-01-11 proj-2 replace std::map w/ fixed size array (avoid linking libstdc) proj-2 CONTROL_MODE MODE_OFF for unused ControlData proj-2 used fixed allocation for controllers and ControlData proj-2 add DISABLE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
2020-01-11 proj-2 HID qa + track latest ui
2020-01-11 proj-2 README update proj-2 runtime_config format proj-2 runtime_config decompress() const
2020-01-11 proj-2 disable EEPROM (at compile time) if device EEPROM is not large enough proj-2 static_assert CONFIG_BYTES is large enough for __RuntimeConfig_v1
2020-01-11 proj-2 TableConfig float datatype for % and temperature steps proj-2 HID dynamic config chunk count proj-2 update CONFIG_KEYs proj-2 track latest UI
2020-01-11 TFC-0 set pin states to default when longer in use TFC-0 README update
2020-01-12 TFC-1 track latest ui
2020-01-16 #3 readme updates #3 readme add PID Usage Example w/ charts
2020-01-16 #3 readme remove image heights
2020-01-17 #1 data payload include aux1Temp, aux2Temp, deltaT #1 qa %-table bugfix #1 qa report correct fan RPM #1 track latest UI
2020-01-17 #3 readme updates
2020-01-25 #1 %-table simplify default values
2020-01-25 #1 track latest UI
2020-01-25 #1 cleanup
2020-02-22 #5 Simple001 PCB schematic, board, and related project files
2020-02-22 #5 Simple001 readme update
2020-02-22 #5 qa Simple001 readme update
2020-02-25 #3 qa readme updates
2020-02-28 #4 project format def, code formats, code cleanup
2020-02-28 #4 support ARDUINO_TEENSY40 constant from later teensy cores release
2020-02-28 #6 migrate __RuntimeConfig_v1 to protobuf (nanopb)
2020-02-28 #4 move c/cpp/proto sources into src/ dir
2020-02-28 #4 add root Makefile for setting up build env
2020-02-28 #4 add teensy_fan_controller Makefile for building project w/o Arduino Studio
2020-02-28 #4 track latest ui_qt5
2020-03-01 #3 #4 README updates/router cooling demo README
2020-03-01 #3 #4 qa router cooling demo README
2020-03-02 #3 doc/ layout for Gitbook
2020-03-02 #3 qa doc/ layout for Gitbook
2020-03-02 #3 remove placeholder hardware docs
2020-03-02 #3 #4 build env. readme, related root Makefile updates
2020-03-02 #3 move READMEs into docs path
2020-03-03 #3 add doc placeholders
2020-03-03 #3 merge root README.md into doc
2020-03-03 GitBook: [master] 30 pages modified
2020-03-03 #3 qa, improve ui/Hardware Setup
2020-03-03 #3 qa
2020-03-03 #3 attempt side-side image without thumbnail
2020-03-03 #3 doc updates
2020-03-03 #4 firmware Makefile allow setting TEENSY from CLI
2020-03-03 #4 breadboard hardware support files
2020-03-03 #4 firmware support Arduino Studio (move teensy_fan_controller.ino to src.ino)
2020-03-03 #4 reference forked PID library, track latest changes
2020-03-03 #4 firmware use PID library as PID<float, float, float>
2020-03-03 #3 README link to Gitbook documentation
2020-03-03 #3 qa README
2020-03-03 GitBook: [master] 15 pages modified
2020-03-04 #3 styled Mangement UI screenshots
2020-03-04 #4 track latest UI
2020-03-04 #3 doc reference latest UI screenshots
2020-03-04 #3 qa doc reference latest renamed UI screenshots
2020-03-04 #4 TempController cleanup: static SAMPLE_PERIOD, typedef PID, const deltaT() and const func ptrs; track latest PID
2020-03-05 #1 fixed control bugfix/save fan off bugfix
2020-03-05 #4 reduce LC memory footprint, reduce string concats, track latest UI
2020-03-06 #1 #4 report %-table PWM % in log, mstrthealias/TFC-ui#2 improve present values, track latest ui
2020-03-07 mstrthealias/TFC-ui#2 track latest ui, attribute flaticon in README
2020-03-08 #4 track latest UI; GIMP assets for UI icon
2020-04-25 #8 hardware move simple001 to simple002
2020-04-25 #8 hardware rename simple001 files to simple002
2020-04-25 #8 hardware correct simple001 board mount hole positions
2020-04-25 #8 hardware simple002 correct fan6 PWM to support Teensy 3.2, 3.5, 3.6, 4.0
2020-04-25 #8 hardware restore published simple001 files
2020-04-25 #8 hardware publish simple002
2020-04-25 #8 hardware move EAGLE to parent directory
2020-04-25 #3 README update
2020-04-25 #3 doc cleanup, UI readme updates
2020-04-25 #3 #8 docs corrent EAGLE/ link
